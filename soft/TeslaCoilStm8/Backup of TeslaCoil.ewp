# IAR project Backup of TeslaCoil.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: C:\Users\Dazer\Documents\GitHub\Tesla_coil_V1\soft\TeslaCoilStm8\inc; C:\Users\Dazer\Documents\GitHub\Tesla_coil_V1\soft\TeslaCoilStm8\rsc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TeslaCoil.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group inc
    inc/: Led.h System.h Timer.h
  group rsc
    rsc/: Led.c System.c Timer.c
