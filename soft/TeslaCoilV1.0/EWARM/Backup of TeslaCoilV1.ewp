# IAR project Backup of TeslaCoilV1.ewp, settings and files
configuration TeslaCoilV1.0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x6
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; C:\Users\Dazer\Desktop\TeslaCoilV1.0\soft\TeslaCoilV1.0\Application\inc; C:\Users\Dazer\Desktop\TeslaCoilV1.0\soft\TeslaCoilV1.0\Application\rsc; C:\Users\Dazer\Desktop\TeslaCoilV1.0\soft\TeslaCoilV1.0\Application\inc\ProcessInputData; C:\Users\Dazer\Desktop\TeslaCoilV1.0\soft\TeslaCoilV1.0\Application\rsc\ProcessInputData; C:\Users\Dazer\Desktop\TeslaCoilV1.0\soft\TeslaCoilV1.0\Application\inc\midi; C:\Users\Dazer\Desktop\TeslaCoilV1.0\soft\TeslaCoilV1.0\Application\rsc\midi
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TeslaCoilV1.0.hex
  ILINK.IlinkOutputFile: TeslaCoilV1.0.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/App/inc
    ../Application/inc/: Bluetooth.h Connection.h LED.h Protection.h Serial.h System.h Timer.h Util.h
  group Application/App/inc/midi
    ../Application/inc/midi/: midi.h Note.h Player.h
  group Application/App/inc/ProcessInputData
    ../Application/inc/ProcessInputData/: ProcessInterrupterData.h ProcessMidiData.h ProcessSystemData.h
  group Application/App/rsc
    ../Application/rsc/: Bluetooth.c Connection.c LED.c Protection.c Serial.c System.c Timer.c Util.c
  group Application/App/rsc/midi
    ../Application/rsc/midi/: midi.c Note.c Player.c
  group Application/App/rsc/ProcessInputData
    ../Application/rsc/ProcessInputData/: ProcessInterrupterData.c ProcessMidiData.c ProcessSystemData.c
  group Application/EWARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
