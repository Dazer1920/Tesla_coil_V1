<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\myProjects\BluetoothChronograph\EWARM\BluetoothChronograph.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TeslaV.1.0.2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\Desktop\Test\Test.ewp</path>
    </project>
    <batchBuild />
</workspace>
