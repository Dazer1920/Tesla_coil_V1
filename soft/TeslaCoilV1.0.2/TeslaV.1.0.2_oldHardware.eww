<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TeslaV.1.0.2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\TeslaCoilV1.0.2_oldHardware\TeslaV.1.0.2.ewp</path>
    </project>
    <batchBuild />
</workspace>
