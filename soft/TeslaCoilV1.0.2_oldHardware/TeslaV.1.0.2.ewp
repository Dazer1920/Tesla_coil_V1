# IAR project TeslaV.1.0.2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030x6
  ICCARM.CCIncludePath2: C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\CMSIS\Device\ST\STM32F0xx\Source\Templates; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\CMSIS\Device\ST\STM32F0xx\Source\Templates\iar; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\CMSIS\Device\ST\STM32F0xx\Include; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\inc; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\inc\midi; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\inc\ProcessingData; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\rsc; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\rsc\midi; C:\Users\Dazer\Documents\myProjects\TeslaCoilV1.0\soft\TeslaCoilV1.0.2_oldHardware\rsc\ProcesingInputData
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TeslaV.1.0.2.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group inc
    inc/: BluetoothConfig.h Led.h Protection.h Serial.h System.h Timers.h Util.h
  group inc/midi
    inc/midi/: MidiControllers.h Player.h ProcessMidiEvents.h
  group inc/ProcessingData
    inc/ProcessingData/: ProcessInterrupterData.h ProcessMidiData.h ProcessSystemData.h
  group rsc
    rsc/: BluetoothConfig.c Led.c Protection.c Serial.c System.c Timers.c Util.c
    CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x6.s
    CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group rsc/midi
    rsc/midi/: MidiControllers.c Player.c ProcessMidiEvents.c
  group rsc/ProcessingData
    rsc/ProcesingInputData/: ProcessInterrupterData.c ProcessMidiData.c ProcessSystemData.c
